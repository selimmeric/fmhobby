# Keil uVision project usb_dongle.uvproj, settings and files
target nrf6905_usb_dongle (MCS-51)
  device: nRFLU1P-F16 Nordic Semiconductor
  cpu: IRAM(0-0xFF) IROM(0-0x3FFF) XRAM (0x8000-0x87FF) CLOCK(16000000) MODC2
  output: nrf6905_usb_dongle +hex
  c flags: Optimize=8
  c define: NRFREADY_DEMO_MODE
  link misc: REMOVEUNUSED
  group Application
    ./: STARTUP.A51 main.c hal_usb.c hal_usb_hid.c
  group USB
    ./: usb_report_desc.c usb_standard_desc.c
